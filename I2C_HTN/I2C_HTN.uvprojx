# Keil uVision project I2C_HTN.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: I2C_HTS +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Core\Inc;.\Core\Src;.\Core\Src;.\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Src/: main.c gpio.c rcc.c
    ./Core/Src/: bh1750.c i2c_driver.c oled_fonts.c oled_graphics.c oled_sh1106.c oled_tests.c sht30.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
